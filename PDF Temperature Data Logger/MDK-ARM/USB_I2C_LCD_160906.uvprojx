# Keil uVision project USB_I2C_LCD_160906.uvprojx, settings and files
target 二次配置单温 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USB_I2C_LCD_160906 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c usbd_msc_data.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User
    ../Src/: usb_device.c usbd_conf.c stm32l0xx_it.c main.c stm32l0xx_hal_msp.c usbd_storage_if.c usbd_desc.c LCD.c fatfs_flash_spi.c diskio.c ff.c button.c pwr.c calendar.c hextode.c uart.c stream1.c malloc.c trees.c zutil.c adc.c deflate.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_spi.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_lcd.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rtc.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
software components: CMSIS:CORE 5.1.1
