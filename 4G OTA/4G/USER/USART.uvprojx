# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\OBJ\wifi.bin .\OBJ\*.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\malloc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\ESP8266;..\Common;..\Test;..\MQTT;..\USART2;..\4G
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c Wenzheng_OTA.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
  group README
    ../: README.TXT
  group ESP8266
    ../ESP8266/: bsp_esp8266.c
  group Common
    ../Common/: Common.c
  group Test
    ../Test/: test.c
  group malloc
    ../malloc/: malloc.c
  group MQTT
    ../MQTT/: MQTT_8266.C
  group usart2
    ../USART2/: usart2.c
  group 4G
    ../4G/: 4G.c
